options:
  parameters:
    generate_options: qt_gui
    id: Receptor_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplificador
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '200'
    value: '100'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: h
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1536000'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: samp_rate_3
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    label0: Señal cuadrada
    label1: Señal binaria?
    label2: Analizador de espectro
    label3: Señal Recibida Absoluta
    label4: Señal Recibida
    num_tabs: '5'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '50000'
    low_cutoff_freq: '10000'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: '50000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '600'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Julian\Desktop\ProgrammingProject\MaquinaNativa2\encrypted_data.bin
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: '8'
    offset: '0'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplificador
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.5'
    threshold_factor_rise: '0.5'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.7'
    init: '0'
    low: '0.7'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Inverse:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] ** -1
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@1
    name: Señal decimada filtrada
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@0
    label1: Señal cuadrada
    name: Señal Cuadrada
    nconnections: '2'
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@3
    label1: Señal Recibida
    name: Señal Recibida Absoluta
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@4
    label1: Señal Recibida
    name: Señal Recibida
    size: '1024'
    srate: samp_rate_2
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: 70e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 200e3
    center_freq0: 830e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_magphase_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_magphase_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_magphase_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', epy_block_0, '0']
- [blocks_delay_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_float_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_threshold_ff_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_threshold_ff_0, '0', fir_filter_xxx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_char_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
