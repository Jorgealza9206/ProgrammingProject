options:
  parameters:
    generate_options: qt_gui
    id: Receptor_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: fff
  states: {state: bypassed}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: 87.5e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [digital_psk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', digital_psk_demod_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']
- [vocoder_cvsd_decode_bf_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
