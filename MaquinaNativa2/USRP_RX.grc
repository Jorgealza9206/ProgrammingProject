options:
  parameters:
    generate_options: qt_gui
    id: USRP_RX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplificador
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '10'
    stop: '1000'
    value: '180'
  states: {}
- name: h
  id: variable
  parameters:
    value: '1'
  states: {}
- name: high
  id: variable
  parameters:
    value: '0.0006'
  states: {}
- name: low
  id: variable
  parameters:
    value: '0.0002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/(sps*2)
  states: {}
- name: th
  id: variable
  parameters:
    value: '0.0004'
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    label0: Señal cuadrada
    label1: Señal decimada
    label2: Diagrama de constelaciones
    label3: Señal Recibida Absoluta
    label4: Señal Recibida
    num_tabs: '5'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate/4
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: samp_rate/4
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/proyecto2/Documentos/ProgrammingProject/MaquinaNativa2/encrypted_data.bin
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: high
    init: '0'
    low: low
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.125'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '11001100101001010100110111110101'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11001100101001010100110111110101'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: bypassed}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Widget@2
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@1
    name: Señal decimada filtrada
    size: '128'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@0
    label1: Señal cuadrada
    name: Señal Cuadrada
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@3
    label1: Señal Recibida
    name: Señal Recibida Absoluta
    size: '64'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@4
    label1: Señal Recibida
    name: Señal Recibida
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: 830e6
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_threshold_ff_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_char_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_float_to_char_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_char_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
