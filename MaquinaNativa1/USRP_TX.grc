options:
  parameters:
    description: https://www.youtube.com/watch?v=2rsu-c26Tqo
    generate_options: qt_gui
    id: USRP
    output_language: python
    title: USRP_4 M-PSK
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(module)
  states: {}
- name: PHG
  id: variable_header_format_default
  parameters:
    access_code: '11001100101001010100110111110101'
    bps: '1'
    threshold: '0'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '195312.5'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Sps_0
  id: variable
  parameters:
    value: int(Sps/2)
  states: {}
- name: TrueBoardConstellation
  id: variable
  parameters:
    value: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: constellation_2
  id: variable
  parameters:
    value: (0,1)
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: module
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,7,1,1
    label: modulación
    label0: TrueBoardConstellation
    label1: constellation_2
    num_opts: '2'
    option0: TrueBoardConstellation
    option1: constellation_2
    options: '[TrueBoardConstellation, constellation_2]'
    type: raw
    value: constellation_2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps*2
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,7
    label0: Señal cuadrada
    label1: Antes de Repeat
    label2: Diagrama de constelaciones
    num_tabs: '3'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Rs*4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/encrypted_data.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: Sps
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '256'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: PHG
    len_tag_key: '"packet_len"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Widget@2
    name: '"Diagrama de constelaciones"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: Widget@0
    name: '"Señal ASK a transmitir"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@4
    name: Antes de Desempaquetar
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: Widget@1
    size: '128'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 830e6
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_1_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
