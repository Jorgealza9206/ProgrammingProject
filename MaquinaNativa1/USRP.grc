options:
  parameters:
    generate_options: qt_gui
    id: USRP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FR_freq
  id: variable_function_probe
  parameters:
    block_id: FR_freq
    function_name: get_number
    poll_rate: '10'
    value: 87.5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '96000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/test_1.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/test_2.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/test_0.bin
    type: short
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/Melendi - Destino o Casualidad ft. Ha Ash VDownloader.wav
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32.763e-6'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 200e3
    center_freq0: 70e6
    dev_addr: ''
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_file_source_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
