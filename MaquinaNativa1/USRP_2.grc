options:
  parameters:
    generate_options: qt_gui
    id: USRP_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Mi unidad\ProgrammingProject\MaquinaNativa1\Melendi - Destino o Casualidad ft. Ha Ash VDownloader.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: 87.5e6
    gain0: '0'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: vocoder_cvsd_encode_fb_0
  id: vocoder_cvsd_encode_fb
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_file_source_0, '0', vocoder_cvsd_encode_fb_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [vocoder_cvsd_encode_fb_0, '0', digital_psk_mod_0, '0']

metadata:
  file_format: 1
