options:
  parameters:
    description: https://www.youtube.com/watch?v=2rsu-c26Tqo
    generate_options: qt_gui
    id: USRP_4
    output_language: python
    title: USRP_4 M-PSK
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(TrueBoardConstellation)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: TrueBoardConstellation
  id: variable
  parameters:
    value: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: constellation_2
  id: variable
  parameters:
    value: (1,0)
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Señal binaria
    label1: Señal cuadrada
    label2: Diagrama de constelaciones
    num_tabs: '3'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Mi unidad/ProgrammingProject/MaquinaNativa1/sample_1.bin
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Mi unidad\ProgrammingProject\MaquinaNativa1\Frailejon.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/alex/Documents/ProgrammingProject/MaquinaNativa1/Melendi - Destino o Casualidad ft. Ha Ash VDownloader.wav
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: (0, 1, 2, 3)
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: TrueBoardConstellation
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Widget@2
    name: '"Diagrama de constelaciones"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate_1
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@1
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@0
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 76.6e6
    gain0: '0'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_file_source_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_complex_to_mag_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
