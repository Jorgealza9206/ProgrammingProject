options:
  parameters:
    author: Alex
    generate_options: qt_gui
    id: Transmitter_1
    output_language: python
    title: HDLC_Transmit
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '40'
  states: {}
- name: interp_0
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: interp*Rb
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: Rb*interp*interp_0
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.1309'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Rb
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\ProgrammingProject\MaquinaNativa1\encrypted_data.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interp
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '256'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate_0
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp_0
    type: ccc
  states: {state: bypassed}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '50'
    preamble_bytes: '100'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 435e6
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', satellites_nrzi_encode_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_hdlc_framer_0, in]
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [satellites_hdlc_framer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_encode_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
