options:
  parameters:
    description: https://www.youtube.com/watch?v=qfOhnqlhmas FAIL
    generate_options: qt_gui
    id: USRP_3
    output_language: python
    title: USRP_3 ASK
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: selector
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label0: txt
    label1: vector
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: Time
    label1: Frequency
    label2: Constellation
    num_tabs: '3'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 48e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_1
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\Mi unidad\ProgrammingProject\MaquinaNativa1\Frailejon.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_1
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 1, 0, 0, 1, 0, 1, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: float
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    name: '"Diagrama de constelaciones"'
    size: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate_1
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 0,0,1,1
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_1, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_selector_0, '0', blocks_repeat_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
