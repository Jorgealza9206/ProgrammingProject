options:
  parameters:
    generate_options: qt_gui
    id: Receptor_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplificador
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '200'
    value: '100'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: h
  id: variable
  parameters:
    value: '1'
  states: {}
- name: high
  id: variable_qtgui_entry
  parameters:
    label: high
    type: real
    value: '4'
  states: {}
- name: low
  id: variable_qtgui_entry
  parameters:
    label: Low
    type: real
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1562500'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: samp_rate_3
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    label0: Señal cuadrada
    label1: Señal decimada
    label2: Diagrama de constelaciones
    label3: Señal Recibida Absoluta
    label4: Señal Recibida
    label5: Antes de desempaquetar
    label6: Symbol Sync
    num_tabs: '7'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '50000'
    low_cutoff_freq: '40000'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: samp_rate
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: e:\Alza\ProgrammingProject\MaquinaNativa2\encrypted_data.bin
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: sps
    offset: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplificador
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: high
    init: '0'
    low: low
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Widget@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@1
    name: Señal decimada filtrada
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@0
    label1: Señal cuadrada
    name: Señal Cuadrada
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@3
    label1: Señal Recibida
    name: Señal Recibida Absoluta
    nconnections: '2'
    size: '1024'
    srate: samp_rate_2
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@4
    label1: Señal Recibida
    name: Señal Recibida
    size: '1024'
    srate: samp_rate_2
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: Widget@5
    name: '"Antes de desempaquetar"'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: 70e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {state: disabled}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 200e3
    center_freq0: 830e6
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0, '0', satellites_nrzi_decode_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
