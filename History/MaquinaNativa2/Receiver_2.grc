options:
  parameters:
    author: Tes America
    generate_options: qt_gui
    id: Receiver_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FSK_Deviation
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/8
  states: {}
- name: cof
  id: variable_qtgui_range
  parameters:
    label: Cut-off Low Pass Filter
    start: '1000'
    step: '1000'
    stop: 200e3
    value: 96e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: '40'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: SDR Receive Frequency
    start: 400e6
    step: '1000'
    stop: 500e6
    value: 435e6
  states: {}
- name: frequency_neg
  id: variable_qtgui_range
  parameters:
    label: Negative Multiplier
    start: '-500000'
    step: '1000'
    stop: '10000'
    value: '-Rb-FSK_Deviation'
  states: {}
- name: gain_quad
  id: variable_qtgui_range
  parameters:
    label: Gain of Demodulation
    start: '1'
    step: '2'
    stop: '200'
    value: '15.2789'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*decim
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: samp_rate*decimation
  states: {}
- name: tw
  id: variable_qtgui_range
  parameters:
    label: Transition Width
    start: '500'
    step: '500'
    stop: '15000'
    value: '1000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: gain_quad
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_neg
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: e:\Alza\ProgrammingProject\MaquinaNativa2\encrypted_data.bin
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '765625e-3'
    mu: '0.5'
    omega: decim
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cof
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: tw
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '0'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Low Pass Filtered"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate_0
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 200e3
    center_freq0: frequency
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate_0
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demodulated
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demodulated
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
