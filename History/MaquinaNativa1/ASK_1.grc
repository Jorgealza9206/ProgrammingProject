options:
  parameters:
    description: Implementación de un sistema de comunicaciones basado en SDR mediante GNU Radio
    generate_options: qt_gui
    id: ASK_1
    output_language: python
    title: ASK_1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: bit
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', pad_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
