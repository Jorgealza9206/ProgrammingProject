options:
  parameters:
    description: https://www.youtube.com/watch?v=2rsu-c26Tqo
    generate_options: qt_gui
    id: fus_USRP_4_with_Pkt_7_base_2
    output_language: python
    title: fus_USRP_4_with_Pkt_7_base_2
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(module)
  states: {state: disabled}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {state: disabled}
- name: Rs
  id: variable
  parameters:
    value: '48828.125'
  states: {state: disabled}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: Sps_0
  id: variable
  parameters:
    value: int(Sps/2)
  states: {state: disabled}
- name: TrueBoardConstellation
  id: variable
  parameters:
    value: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
  states: {state: disabled}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {state: disabled}
- name: constellation_2
  id: variable
  parameters:
    value: (0,1)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: module
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,7,1,1
    label: modulación
    label0: TrueBoardConstellation
    label1: constellation_2
    num_opts: '2'
    option0: TrueBoardConstellation
    option1: constellation_2
    options: '[TrueBoardConstellation, constellation_2]'
    type: raw
    value: constellation_2
  states: {state: disabled}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {state: disabled}
- name: samp_rate_2
  id: variable
  parameters:
    value: samp_rate*16
  states: {state: disabled}
- name: Widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,7
    label0: Señal binaria
    label1: Señal cuadrada
    label2: Diagrama de constelaciones
    label3: Antes de Chunks
    num_tabs: '4'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: G:\My Drive\ProgrammingProject\MaquinaNativa1\encrypted_data_rr.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: G:\My Drive\ProgrammingProject\MaquinaNativa1\encrypted_data_rr.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: G:\My Drive\ProgrammingProject\MaquinaNativa1\Frailejon.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '8'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_2
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,1,0,0,1,1,0,0,1,0,1,0,0,1,0,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: module
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {state: disabled}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {state: disabled}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"burst"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: Widget@2
    name: '"Diagrama de constelaciones"'
    size: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate_1
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: Widget@1
    name: '"Señal cuadrada"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@0
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: Widget@3
    name: Antes de Chunks
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 830e6
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_pdu_to_tagged_stream_2, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_tag_debug_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_pdu_to_tagged_stream_2, pdus]
- [blocks_tagged_stream_to_pdu_0_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_1_0, '0']
- [blocks_vector_source_x_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_crc32_async_bb_0, out, blocks_message_debug_1, print]
- [digital_crc32_async_bb_1, out, digital_protocol_formatter_async_0, in]
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1, '0']
- [digital_protocol_formatter_async_0, header, blocks_message_debug_0, print]
- [digital_protocol_formatter_async_0, header, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, blocks_message_debug_0, print]
- [digital_protocol_formatter_async_0, payload, blocks_pdu_to_tagged_stream_1, pdus]
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [interp_fir_filter_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_1, '0', digital_header_payload_demux_0, '0']
- [virtual_source_1_0, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_1_0, '0', digital_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
