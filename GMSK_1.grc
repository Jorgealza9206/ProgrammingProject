options:
  parameters:
    author: Julian
    generate_options: qt_gui
    id: GMSK_1
    output_language: python
    title: GMSK_1
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: freq
    type: real
    value: 830e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_32
    file: C:\Users\Julian\Desktop\ProgrammingProject\MaquinaNativa2\Melendi.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: freq
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: vocoder_cvsd_decode_bf_0
  id: vocoder_cvsd_decode_bf
  parameters:
    bw: '0.5'
    resample: '8'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [digital_gmsk_demod_0, '0', vocoder_cvsd_decode_bf_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', audio_sink_0, '0']
- [vocoder_cvsd_decode_bf_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
